KERNEL_MODULE_AUTOLOAD += "i2c-dev"
