FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://my_frag.cfg"
