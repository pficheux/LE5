DESCRIPTION = "LE5 distro image"
include rpi-le5-image.bb


